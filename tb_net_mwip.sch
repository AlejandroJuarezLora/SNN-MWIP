** sch_path: tb_net_mwip.sch
**.subckt tb_net_mwip
x1 VDD GND e_x tau_nom x_nom dx_nom th_nom dth_nom e_th 4x1_net
XM1 x dx th dth tau mwip_v0
V1 VDD GND 1.8
alimit1 %vd( dth GND ) %vd( net1 GND ) alimit1
.model alimit1 limit ( gain='0.9/5' out_lower_limit=0 out_upper_limit=0.9 )
alimit2 %vd( th GND ) %vd( net2 GND ) alimit2
.model alimit2 limit ( gain='0.9/0.4148' out_lower_limit=0 out_upper_limit=0.9 )
alimit3 %vd( dx GND ) %vd( net3 GND ) alimit3
.model alimit3 limit ( gain='0.9/5' out_lower_limit=0 out_upper_limit=0.9 )
alimit4 %vd( x GND ) %vd( net4 GND ) alimit4
.model alimit4 limit ( gain='0.9/4.8' out_lower_limit=0 out_upper_limit=0.9 )
V2 dth_nom net1 0.9
V3 th_nom net2 0.9
V4 dx_nom net3 0.9
V5 x_nom net4 0.9
alimit5 %vd( x x_ref ) %vd( net5 GND ) alimit5
.model alimit5 limit ( gain='1.8/5' out_lower_limit=-0.9 out_upper_limit=0.9 )
alimit6 %vd( th th_ref ) %vd( net6 GND ) alimit6
.model alimit6 limit ( gain='1.8/5' out_lower_limit=-0.9 out_upper_limit=0.9 )
V6 x_ref GND 2.5
V7 e_x net5 0.9
V8 e_th net6 0.9
V9 th_ref GND 0
alimit7 %vd( tau_nom GND ) %vd( tau GND ) alimit7
.model alimit7 limit ( gain=100 out_lower_limit=-1 out_upper_limit=1 )
**** begin user architecture code

*MADE BY JORGE ALEJANDRO JUAREZ LORA IPN

.subckt rram_v1 TE BE
    N1 TE BE rram_v1_model gap_initial=unif(0.9,0.79)
    *N1 TE BE rram_v1_model
.ends rram_v1

.subckt mwip_v0 tau x th dx dth
    N1 Tau x th dx dth mwip_v0_model
.ends mwip_v0

.model mwip_v0_model mwip_dynamics
.model rram_v1_model rram_v1_va

.control
    pre_osdi /foss/designs/SNN-MWIP/Memristor/rram_v1.osdi
    pre_osdi /foss/designs/SNN-MWIP/MWIP/mwip.osdi
.endc

.lib $::SKYWATER_MODELS/sky130.lib.spice tt


.options method gear
.options KLU
.options noinit
.options set num_threads=8
.options set ng_nomodcheck
.options set skywaterpdk
.options set wr_vecnames
.options set wr_singlescale
.options numdgt = 2
*.save tau x dx th dth tau x_nom dx_nom th_nom dth_nom tau_nom e_x e_th
.tran 50n 1u uic
.control
	run
	write /foss/designs/SNN-MWIP/data.raw
.endc



**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
.end
