** sch_path: 4x1_net.sch
**.subckt 4x1_net x1 avdd avss y1 R1 x2 x3 x4 R2
*.ipin x1
*.iopin avdd
*.iopin avss
*.iopin y1
*.iopin R1
*.ipin x2
*.ipin x3
*.ipin x4
*.iopin R2
x1 avdd avss x1 net10 net8 net7 net9 layer_input
x7 net17 GND net25 net8 avdd net9 net23 net1 net4 net6 net11 net13 net15 net7 net2 net5 net3 net10
+ net12 net14 net16 net26 net27 net28 net24 net21 net22 net18 net19 net20 stdp_8x4
x8 avdd net17 GND net25 y1 R1 R2 net23 net26 net27 net28 net24 net21 net22 net18 net19 net20
+ layer_output_rew
x2 avdd avss x2 net12 net1 net2 net11 layer_input
x3 avdd avss x3 net14 net4 net5 net13 layer_input
x4 avdd avss x4 net16 net6 net3 net15 layer_input
**.ends
.GLOBAL avss
.GLOBAL avdd
.GLOBAL GND
.end
