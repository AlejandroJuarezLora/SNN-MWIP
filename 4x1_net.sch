** sch_path: 4x1_net.sch
**.subckt 4x1_net x1 avdd avss y1 R1 x2 x3 x4 R2
*.ipin x1
*.iopin avdd
*.iopin avss
*.iopin y1
*.iopin R1
*.ipin x2
*.ipin x3
*.ipin x4
*.iopin R2
x1 avdd avss x1 hJ1 hJ1 hJ1 hJ1 layer_input
x6 avdd net2[7] net2[6] net2[5] net2[4] net2[3] net2[2] net2[1] net2[0] avss hK1 hK1 hK1 hK1 hK1 hK1
+ hK1 hK1 layer_hidden
x7 net1[3] net1[2] net1[1] net1[0] GND hL1 hL1 hL1 hL1 hK1 hK1 hK1 hK1 hK1 hK1 hK1 hK1 avdd stdp_8x4
x8 avdd net1[3] net1[2] net1[1] net1[0] GND hL1 hL1 hL1 hL1 y1 R1 R2 layer_output_rew
x2 avdd avss x2 hJ2 hJ2 hJ2 hJ2 layer_input
x3 avdd avss x3 hJ3 hJ3 hJ3 hJ3 layer_input
x4 avdd avss x4 hJ4 hJ4 hJ4 hJ4 layer_input
x5 avdd net2[7] net2[6] net2[5] net2[4] net2[3] net2[2] net2[1] net2[0] avss hK1 hK1 hK1 hK1 hK1 hK1
+ hK1 hK1 hJ1 hJ1 hJ1 hJ1 hJ2 hJ2 hJ2 hJ2 hJ3 hJ3 hJ3 hJ3 hJ4 hJ4 hJ4 hJ4 no_stdp_4x4x8
**.ends
.GLOBAL avss
.GLOBAL avdd
.GLOBAL GND
.end
