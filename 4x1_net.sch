** sch_path: 4x1_net.sch
**.subckt 4x1_net x1 avdd avss y1 R1 x2 x3 x4 R2
*.ipin x1
*.iopin avdd
*.iopin avss
*.iopin y1
*.iopin R1
*.ipin x2
*.ipin x3
*.ipin x4
*.iopin R2
x1 avdd avss x1 net4 j1 j2 net3 layer_input
x7 net9 GND k4 j1 avdd net3 net15 j3 j7 net2 j5 net5 net7 j2 j4 j8 net1 net4 j6 net6 net8 k3 k2 k1
+ net16 net13 net14 net10 net11 net12 stdp_8x4
x8 avdd net9 GND k4 y1 R1 R2 net15 k3 k2 k1 net16 net13 net14 net10 net11 net12 layer_output_rew
x2 avdd avss x2 j6 j3 j4 j5 layer_input
x3 avdd avss x3 net6 j7 j8 net5 layer_input
x4 avdd avss x4 net8 net2 net1 net7 layer_input
**** begin user architecture code


.save v(j1) v(j2) v(j3) v(j4) v(j5) v(j6) v(j7) v(j8)
.save v(k1) v(k2) v(k3) v(k4)


**** end user architecture code
**.ends
.GLOBAL avss
.GLOBAL avdd
.GLOBAL GND
.end
