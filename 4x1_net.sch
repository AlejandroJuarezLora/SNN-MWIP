** sch_path: 4x1_net.sch
**.subckt 4x1_net x1 avdd avss y1 R1 x2 x3 x4 R2
*.ipin x1
*.iopin avdd
*.iopin avss
*.iopin y1
*.iopin R1
*.ipin x2
*.ipin x3
*.ipin x4
*.iopin R2
x1 avdd avss x1 net3[3] net3[2] net3[1] net3[0] layer_input
x7 net1[3] net1[2] net1[1] net1[0] GND hL1 hL1 hL1 hL1 net4[7] net4[6] net4[5] net4[4] net4[3]
+ net4[2] net4[1] net4[0] avdd stdp_8x4
x8 avdd net1[3] net1[2] net1[1] net1[0] GND hL1 hL1 hL1 hL1 y1 R1 R2 net2[3] net2[2] net2[1] net2[0]
+ layer_output_rew
x2 avdd avss x2 net5[3] net5[2] net5[1] net5[0] layer_input
x3 avdd avss x3 net6[3] net6[2] net6[1] net6[0] layer_input
x4 avdd avss x4 net7[3] net7[2] net7[1] net7[0] layer_input
**.ends
.GLOBAL avss
.GLOBAL avdd
.GLOBAL GND
.end
